VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO gf180mcu_gsd__logo
  CLASS BLOCK ;
  FOREIGN gf180mcu_gsd__logo ;
  ORIGIN 0.000 0.000 ;
  SIZE 190.5 BY 162 ;
  OBS
      LAYER Metal5 ;
        RECT 0.0 0.0 97.8 85 ;
        RECT 0.0 85 150 124 ;
        RECT 0.0 124 190.5 162 ;
  END
END gf180mcu_gsd__logo
END LIBRARY

